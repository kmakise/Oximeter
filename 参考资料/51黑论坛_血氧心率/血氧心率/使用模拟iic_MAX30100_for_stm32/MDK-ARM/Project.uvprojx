# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER\SetUp;..\USER;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Drivers\delay;..\Drivers\Usart;..\Drivers\Rotating_Disk_Mechanism;..\Drivers\Ultrasonic;..\Drivers\delayL;..\Drivers\sys;..\Drivers\OED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: stm32f10x_it.c main.c bsp_i2c_gpio.c
  group Stdperiph_Driver
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Delay
    ../Drivers/delay/: delay.c
  group Usart
    ../Drivers/Usart/: USART.c
  group Ultrasonic
    ../Drivers/Ultrasonic/: ultrasonic.c
  group SYS
    ../Drivers/sys/: sys.c
  group Delayl
    ../Drivers/delayL/: delayl.c
  group OLED
    ../Drivers/OED/: oled.c
software components: CMSIS:CORE 5.3.0
